# Repository Battosai42/amcp

File README.md:

# amcp
**WORK IN PROGRESS!**

ampc is an automated measurement tool of crystal parameters using a vector network analyser. 

## Project Description
This Project is intended to automate the measurement of crystals up to about 150MHz using a cheap VNA such as the miniVNA or nanoVNA. The measurement method requires a passive test-fixture according to IEC-444 which is a douple-pi network terminating the crystal at 12.5Ohm.

## Feedback
I would be very interessted to hear some feedback from people finding this project interessting, have suggestions or even started using it. Please contact me by mail (git.b42@gmail.com).

## Project Status
The calculation of the motional parameters is still not reliable in all cases and special care has to be taken for the measurement setup. Good calibration of the VNA is essential to get Rs right. Also the impedance matching to the crystal is very important as the calculation of the other motional parameters are relying on a goot match.

### Software
- [X] Basic Gui
- [X] Basic Functions
  - [X] Phase-Shift Method
  - [X] -3dB Bandwidth Method
  - [X] Export as SPICE/Spectre model file (untested)
  - [X] Save/Load Tool Setup
- [ ] Advanced Functions
  - [ ] Support Threading
  - [ ] Automated VNA setup for easier use

#### Hardware Support
- [X] miniVNA tiny 
- [X] nanoVNA 
- [ ] Generic Wrapper for other VNAs

### Hardware
- [ ] Example Test-Fixture (IEC-444)

## KiCad design acmp_test_fixture/AXS-socket-only-variant/acmp_test_fixture.kicad_pcb

File acmp_test_fixture/README.md:

# Test-Fixture (KiCad)
The design files for the test-fixture are designed using Kicad 5.0.2

## BOM
..todo

Parts:
J1, J2, J3, J4: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount
Y1: AXS-3225-04-02
Y2: AXS-3225-04-02; AXS-2016-04-04

Connections:
GND: J1.2 (Ext), J2.2 (Ext), J3.2 (Ext), J4.2 (Ext), Y1.2, Y1.4, Y2.2, Y2.4
unnamed: J1.1 (In), Y1.1
unnamed: J2.1 (In), Y1.3
unnamed: J3.1 (In), Y2.3
unnamed: J4.1 (In), Y2.1

Notes on the sheet:
Crystal sees 25 Ohm CL=19 pF
50 Ohm to VNA

Board: 2 copper layers, 38.1 x 50.8 mm, 6 parts (2 on the bottom side), 5 nets.

## KiCad design acmp_test_fixture/AXS-socket-variant/acmp_test_fixture.kicad_pcb

Parts:
C1, C2, C3, C4: 33n; C_0603_1608Metric
J1, J2, J3, J4: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount
R1, R6, R7, R12: 158R; R_0603_1608Metric
R2, R5, R8, R11: 66R5; R_0603_1608Metric
R3, R4, R9, R10: 14R2; R_0603_1608Metric
Y1: AXS-3225-04-02
Y2: AXS-3225-04-02; AXS-2016-04-04

Connections:
GND: C1.2, C2.2, C3.2, C4.2, J1.2 (Ext), J2.2 (Ext), J3.2 (Ext), J4.2 (Ext), R1.2, R3.2, R4.2, R6.2, R7.2, R9.2, R10.2, R12.2, Y1.2, Y1.4, Y2.2, Y2.4
unnamed: C1.1, R2.1, R3.1, Y1.1
unnamed: C2.1, R4.1, R5.2, Y1.3
unnamed: C3.1, R8.1, R9.1, Y2.3
unnamed: C4.1, R10.1, R11.2, Y2.1
unnamed: J1.1 (In), R1.1, R2.2
unnamed: J2.1 (In), R5.1, R6.1
unnamed: J3.1 (In), R7.1, R8.2
unnamed: J4.1 (In), R11.1, R12.1

Notes on the sheet:
Crystal sees 25 Ohm CL=19 pF
50 Ohm to VNA
12.5Ohm

Board: 2 copper layers, 34.3 x 63.5 mm, 22 parts (2 on the bottom side), 9 nets.

## Commit log

2019-08-24 added basic description
2019-08-24 initial commit of basic files
2019-08-24 removed empty folder
2019-08-25 some progress on gui
2019-08-25 addded vnaj setup files
2019-08-28 vnaJ-hl working
2019-08-28 added calibration file
2019-08-28 added readme to vnaJ folder
2019-08-28 fixed typo
2019-08-28 progress update
2019-08-28 added link to license
2019-11-26 added kicad library as submodule
2019-11-26 moved submodule in subdirectory
2019-11-26 added B42 libraries
2019-11-27 initial pcb design for the test fixture
2019-11-27 slow progress
2020-01-02 switched to qt5 for gui design
2020-01-02 added readme for gui
2020-01-03 gui progressing
2020-01-04 baisc gui working with vnaJ
2020-01-04 minor update
2020-01-04 added gui functions load from file
2020-01-07 cleanup session
2020-01-14 added simulation results of RSX11 model for testing
2020-01-14 bugfix in phaseshift.py
2020-01-14 updated picture
2020-01-17 fixed a bug related to data load
2020-01-17 added better example
2020-01-17 implemented save/load function
2020-01-17 added variant of test fixture
2020-01-17 added -3dB method and code cleanup
2020-02-22 added nanovna support
2020-02-22 fixed bug: frequency range
2020-02-24 added variable setup impedance
2020-02-24 nanovna fixed set frequencies
2020-02-24 updated executable
